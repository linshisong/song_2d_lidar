# Keil uVision project 2D-Lidar.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F302CB STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.3.0
  cpu: IROM(0x08000000,0x00020000) IRAM(0x20000000,0x00006000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: 2D-Lidar +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F302x8
  c include: .\CMSIS;.\Drivers;.\FWlib\inc;.\FWlib\src;.\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x6000
  group User
    ./User/: main.c stm32f30x_it.c SysTick.c
  group CMSIS
    ./CMSIS/: startup_stm32f302x8.s system_stm32f30x.c
  group FWlib
    ./FWlib/src/: stm32f30x_adc.c stm32f30x_dma.c stm32f30x_gpio.c stm32f30x_i2c.c stm32f30x_usart.c stm32f30x_tim.c stm32f30x_rcc.c stm32f30x_exti.c
  group Drivers
    ./Drivers/I2C/: i2c.c
    ./Drivers/LED/: LED.c
    ./Drivers/USART/: uart.c
